#include <stdio.h>
#include <limits.h>
#include <ctype.h>

// ============================================================================
// 題目 3【字串轉整數 / 簡化版 atoi (String to Integer - LeetCode #8)】
// 難度：🟡 一線 IC 設計廠 & 系統廠通訊協議/CLI/Driver 解析必備題
// 出題頻率：🔥🔥🔥🔥🔥 (考字串狀態機、空白處理、正負號與溢位保護)
// 題目說明：請你實作一個 my_atoi(char* s) 函式，使其能將字串轉換成一個 32 位元有號整數：
//    1. 忽略前導空白字元。
//    2. 檢查下一個字元（若未到達結尾）是否為正負號 ('-' 或 '+')，若無則預設為正。
//    3. 讀取後續數字直到非數字字元或到達字串結尾，忽略其餘字元。
//    4. 若數字超出 32 位元有號整數範圍 [-2^31, 2^31 - 1]，請依規律截斷至 INT_MAX 或 INT_MIN！
//    5. 若未讀取到任何有效數字，返回 0。
// 範例 1：
//    輸入：s = "42"
//    輸出：42
// 範例 2：
//    輸入：s = "   -42"
//    輸出：-42
// 範例 3：
//    輸入：s = "4193 with words"
//    輸出：4193
// 範例 4：
//    輸入：s = "-91283472332"
//    輸出：-2147483648 (截斷至 INT_MIN)
// 限制條件：
//    - 0 <= s.length <= 200
//    - s 由英文字母、數字、空白與 '+', '-', '.' 組成
//    - ⚠️ 請務必在累加過程中嚴密防範整數溢位 (Integer Overflow)！
// ============================================================================

int my_atoi(char* s) {
    if (s == NULL) return 0;

    int i = 0;
    // 1. 忽略前導空白字元
    while (s[i] == ' ') {
        i++;
    }

    // 2. 檢查正負號
    int sign = 1;
    if (s[i] == '+' || s[i] == '-') {
        if (s[i] == '-') {
            sign = -1;
        }
        i++;
    }

    // 3. 逐位解析數字，遇非數字立即中斷，並在乘 10 前嚴密防範 32 位元溢位
    long long result = 0;
    while (s[i] >= '0' && s[i] <= '9') {
        int digit = s[i] - '0';

        // 防溢位檢查：若 result * 10 + digit > INT_MAX 則立即截斷
        if (result > (INT_MAX - digit) / 10) {
            return (sign == 1) ? INT_MAX : INT_MIN;
        }

        result = result * 10 + digit;
        i++;
    }

    return (int)(sign * result);
}

/*
 * ============================================================================
 * 🔍 使用者原始白板程式碼存檔 (Original Implementation Archive)
 * ============================================================================
 * 【原始完整程式碼】：
 * int my_atoi(char* s) {
 *     int minus = 1;
 *     int len = strlen(s);
 *     long result = 0;
 *     for(int i = 0; i < len; i++)
 *     {
 *         if(s[i] == '-')
 *         {
 *             minus = -1;
 *         }
 *         if(s[i] >= '0' && s[i] <= '9')
 *         {
 *             if(result * 10 > INT_MAX)
 *             {
 *                 return INT_MAX;
 *             }
 *             else if(result * 10 < INT_MIN)
 *             {
 *                 return INT_MIN;
 *             }
 *             else
 *             {
 *                 result = result * 10;
 *             }
 *             result += (int) s[i];
 *         }
 *     }
 *     
 *     return result;
 * }
 * 
 * 【原始寫法四大盲點剖析】：
 *   1. ASCII 轉數值未減 '0'：
 *      - 原寫法寫成 `result += (int) s[i];`，字元 '4' 的 ASCII 為 52，而非整數值 4！
 *      - 導致 "42" 被算成了 52*10 + 50 = 570。正確需寫 `s[i] - '0'`。
 *   2. 正負號未套用至最終結果：
 *      - 雖然宣告了 `minus = -1`，但最後 `return result;` 依然是正數，"-42" 變成了正數。
 *   3. 缺乏狀態機中斷邏輯 (遇非數字應立即停止)：
 *      - 原程式用 for 迴圈無條件掃描完整字串，導致 "words and 987" 會跳過英文強行解析 987；
 *      - 依 atoi 規範，開頭遇到非空白非正負號之字母，應立即終止回傳 0。
 *   4. 整數溢位檢查時機與型態 (Signed Overflow)：
 *      - 在 Windows MSVC 平台下 `long` 與 `int` 均為 32 位元，`result * 10` 在運算時就會先溢位！
 *      - 應使用安全的反向防護 `result > (INT_MAX - digit) / 10`，或使用 64 位元 `long long` 暫存。
 * ============================================================================
 */

int main(void) {
    /* 測試測資 1: "42" -> 42 */
    printf("測資 1 (\"42\"): %d (預期: 42)\n", my_atoi("42"));

    /* 測試測資 2: "   -42" -> -42 */
    printf("測資 2 (\"   -42\"): %d (預期: -42)\n", my_atoi("   -42"));

    /* 測試測資 3: "4193 with words" -> 4193 */
    printf("測資 3 (\"4193 with words\"): %d (預期: 4193)\n", my_atoi("4193 with words"));

    /* 測試測資 4: "words and 987" -> 0 */
    printf("測資 4 (\"words and 987\"): %d (預期: 0)\n", my_atoi("words and 987"));

    /* 測試測資 5: 負數溢位 "-91283472332" -> INT_MIN (-2147483648) */
    printf("測資 5 (\"-91283472332\"): %d (預期: %d)\n", my_atoi("-91283472332"), INT_MIN);

    /* 測試測資 6: 正數溢位 "2147483648" -> INT_MAX (2147483647) */
    printf("測資 6 (\"2147483648\"): %d (預期: %d)\n", my_atoi("2147483648"), INT_MAX);

    return 0;
}
