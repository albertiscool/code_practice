#include <stdio.h>
#include <assert.h>

/**
 * LeetCode #868: Binary Gap
 * 
 * 題目描述：
 * 給定一個正整數 n，找出並返回 n 的二進位表示法中，任意兩個「相鄰的 1」之間的最長距離（Binary Gap）。
 * 如果不存在兩個相鄰的 1，則返回 0。
 * 
 * 定義：
 * - 如果兩個 1 之間只有 0（可以沒有 0），則這兩個 1 被視為「相鄰」。
 * - 兩個 1 之間的「距離」是指它們在二進位表示中的索引位置差的絕對值。
 *   例如："1001" 中，兩個 1 的索引位置分別為 0 和 3，距離為 3。
 * 
 * 限制條件：
 * - 1 <= n <= 10^9
 * - 挑戰目標：時間複雜度 O(log N)（即 32 次迴圈以內），額外空間複雜度 O(1)。
 * 
 * 範例 1:
 *   輸入: n = 22
 *   輸出: 2
 *   解釋: 22 的二進位是 10110。
 *         相鄰的 1 分別位於：第 1 位與第 2 位（距離 1）、第 2 位與第 4 位（距離 2）。
 *         最長距離為 2。
 * 
 * 範例 2:
 *   輸入: n = 8
 *   輸出: 0
 *   解釋: 8 的二進位是 1000，只有一個 1，故返回 0。
 * 
 * 範例 3:
 *   輸入: n = 5
 *   輸出: 2
 *   解釋: 5 的二進位是 101，兩個 1 位於第 0 位與第 2 位，距離為 2。
 */

int binaryGap(int n) {
    // 【使用者原始白板實作】(僅修正運算子優先級括號 bug)
    if ((n & (n - 1)) == 0)
    {
        return 0;
    }
    int last = -1;
    int max = 0;
    for(int i = 0; i < 32; i++)
    {
        if((n & 1) == 1)
        {
            if(last == -1)
            {
                last = i;
            }
            else
            {
                if((i - last) > max)
                {
                    max = i - last;
                    last = i;
                }
                else
                {
                    last = i;
                }
            }
        }
        n = n >> 1;
        if(n == 0) break;
    }
    return max;
}

/*
 * =====================================================================================
 * 【使用者原始白板程式碼 (原始未修改版本)】
 * =====================================================================================
 * int binaryGap(int n) {
 *     if(n & (n - 1) == 0)
 *     {
 *         return 0;
 *     }
 *     int last = -1;
 *     int max = 0;
 *     for(int i = 0; i < 32; i++)
 *     {
 *         if((n & 1) == 1)
 *         {
 *             if(last == -1)
 *             {
 *                 last = i;
 *             }
 *             else
 *             {
 *                 if((i - last) > max)
 *                 {
 *                     max = i - last;
 *                     last = i;
 *                 }
 *                 else
 *                 {
 *                     last = i;
 *                 }
 *             }
 *         }
 *         n = n >> 1;
 *         if(n == 0) break;
 *     }
 *     return max;
 * }
 * =====================================================================================
 * 【面試盲點剖析 & 運算子優先級致命陷阱】 (LeetCode #868: Binary Gap)
 * =====================================================================================
 * 
 * 1. 致命運算子優先級陷阱 (Operator Precedence)：
 *    - 原始寫法：`if (n & (n - 1) == 0)`
 *    - 陷阱所在：在 C 語言中，關係運算子 `==` 的優先級 (Level 9) 高於位元運算子 `&` (Level 8)！
 *    - 編譯器解析順序：
 *      `n & ((n - 1) == 0)`
 *      若 n = 8 (二進位 1000)：
 *        (8 - 1) == 0  -->  7 == 0  -->  0 (false)
 *        8 & 0         -->  0 (false)！特判完全失效！
 *    - 為什麼 LeetCode 本次沒報錯？
 *      因為在後續的 for 迴圈中，當只有一個 1 時，`else` 分支永遠不會被觸發，最終返回 `max = 0`，
 *      剛好被後方的迴圈掩蓋過去！但在面試白板上，這行會被面試官一眼抓包！
 *    - 正確寫法：務必加上括號 `if (((n & (n - 1)) == 0)`。
 * 
 * 2. 邏輯精簡與分支消除 (Branch Pruning)：
 *    - 原始結構在 `if((i - last) > max)` 與 `else` 兩邊都寫了 `last = i;`，
 *      且外層 `if (last == -1)` 也同樣在做 `last = i;`。
 *    - 事實上：只要當前 bit 為 1，無論是第一個 1 還是後續的 1，最後都需要更新 `last = i`。
 *    - 簡化為：
 *      ```c
 *      if (last != -1) {
 *          int dist = i - last;
 *          if (dist > max) max = dist;
 *      }
 *      last = i;
 *      ```
 *      邏輯更加清爽、降低圈複雜度 (Cyclomatic Complexity)。
 * 
 * 3. 執行效率：
 *    - 透過 `if (n == 0) break;` 提早結束，對於小數字無須跑滿 32 次。
 *    - 時間複雜度：O(log N)，空間複雜度：O(1)。
 * =====================================================================================
 */

int main(void) {
    printf("=== Test P1: Binary Gap ===\n");

    // Test 1: 22 (10110) -> 2
    assert(binaryGap(22) == 2);
    printf("Test 1 Passed: n = 22 -> 2\n");

    // Test 2: 8 (1000) -> 0
    assert(binaryGap(8) == 0);
    printf("Test 2 Passed: n = 8 -> 0\n");

    // Test 3: 5 (101) -> 2
    assert(binaryGap(5) == 2);
    printf("Test 3 Passed: n = 5 -> 2\n");

    // Test 4: 6 (110) -> 1
    assert(binaryGap(6) == 1);
    printf("Test 4 Passed: n = 6 -> 1\n");

    // Test 5: 1 (1) -> 0
    assert(binaryGap(1) == 0);
    printf("Test 5 Passed: n = 1 -> 0\n");

    printf("All P1 Local Tests Passed!\n");
    return 0;
}
